# Keil uVision project D8B-QuickCharger.uvprojx, settings and files
target D8BQuickCharger (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F52342_33QFN Holtek
  pack: Holtek.HT32_DFP.1.0.44
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: D8BFastCharge +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52342
  c include: .\User\inc;.\Config;.\MDK-ARM;.\CMSIS\Core\Include;.\CMSIS\Include;.\Library\inc;.\OLED
  asm define: USE_HT32_CHIP=4
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: main.c ht32f5xxxx_01_it.c delay.c LinearTabOp.c MCUBeatTimer.c
  group Config
    ./Config/: ht32_op.s ht32_board_config.h ht32f5xxxx_01_usbdconf.h ht32f5xxxx_02_usbdconf.h ht32f5xxxx_conf.h HT32F5xxxx_01_DebugSupport.ini Pindefs.h
  group CMSIS
    ./CMSIS/: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./MDK-ARM/: startup_ht32f5xxxx_01.s
  group Library
    ./Library/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group ExtPeriphals
    ./ExtPeriphal/: LEDMgmt.c SideKey.c FlashProt.c I2CDrv.c IP2368.c
  group Logic
    ./Logic/: Menu.c LED.c PowerMgmt.c Config.c
  group OLED
    ./OLED/: OLEDDisplayWidgets.c oleddrv.c oled.h
